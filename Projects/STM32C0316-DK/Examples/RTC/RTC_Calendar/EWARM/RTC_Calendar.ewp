# IAR project RTC_Calendar.ewp, settings and files
configuration RTC_Calendar (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32C031xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32C0316-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_Calendar.hex
  ILINK.IlinkOutputFile: RTC_Calendar.out
  ILINK.IlinkIcfFile: stm32c031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32C0316-DK
    ../../../../../../Drivers/BSP/STM32C0316-DK/: stm32c0316_discovery.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_rtc.c stm32c0xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c

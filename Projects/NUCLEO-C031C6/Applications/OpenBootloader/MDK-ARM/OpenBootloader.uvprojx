# Keil uVision project OpenBootloader.uvprojx, settings and files
target NUCLEO-C031C6 (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IROM(0x08000000-0x8003BFF) IRAM(0x20000000-0x200017FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32C031xx
  c include: ../Core/Inc;../OpenBootloader/App;../OpenBootloader/Target;../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Modules/I2C;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Middlewares/ST/OpenBootloader/Modules/USART
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/Core
    ../Core/Src/: main.c stm32c0xx_hal_msp.c stm32c0xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_dma.c stm32c0xx_hal_exti.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_iwdg.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_usart.c stm32c0xx_hal_usart_ex.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_ll_i2c.c stm32c0xx_ll_pwr.c stm32c0xx_ll_rcc.c stm32c0xx_ll_usart.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
software components: CMSIS:CORE 5.5.0

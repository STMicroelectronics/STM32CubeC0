# IAR project OpenBootloader.ewp, settings and files
configuration NUCLEO-C031C6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32C031xx
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\OpenBootloader\App; ..\OpenBootloader\Target; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32C0xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\I2C; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\Mem; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USART
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenBootloader.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32c031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: main.c stm32c0xx_hal_msp.c stm32c0xx_it.c
  group Application/EWARM
    ./: startup_stm32c031xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_dma.c stm32c0xx_hal_exti.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_iwdg.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_usart.c stm32c0xx_hal_usart_ex.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_ll_i2c.c stm32c0xx_ll_pwr.c stm32c0xx_ll_rcc.c stm32c0xx_ll_usart.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c

# Keil uVision project USART_SyncCommunication_FullDuplex_IT_Init.uvprojx, settings and files
target USART_SyncCommunication_FullDuplex_IT_Init (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.0.0.1
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: USART_SyncCommunication_FullDuplex_IT_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C031xx
  c include: ../Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_dma.c stm32c0xx_ll_spi.c stm32c0xx_ll_usart.c stm32c0xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0

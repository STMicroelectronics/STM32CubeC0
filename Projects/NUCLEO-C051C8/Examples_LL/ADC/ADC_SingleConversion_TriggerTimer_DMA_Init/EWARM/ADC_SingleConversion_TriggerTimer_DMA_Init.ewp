# IAR project ADC_SingleConversion_TriggerTimer_DMA_Init.ewp, settings and files
configuration ADC_SingleConversion_TriggerTimer_DMA_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32C051C8 ST STM32C051C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=48000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32C051xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_SingleConversion_TriggerTimer_DMA_Init.hex
  ILINK.IlinkOutputFile: ADC_SingleConversion_TriggerTimer_DMA_Init.out
  ILINK.IlinkIcfFile: stm32c051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c051xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_ll_adc.c stm32c0xx_ll_dma.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_pwr.c stm32c0xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c

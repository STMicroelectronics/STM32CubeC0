# IAR project RCC_UseHSEasSystemClock.ewp, settings and files
configuration RCC_UseHSEasSystemClock (ARM, debug)
  General.OGChipSelectEditMenu: STM32C051C8 ST STM32C051C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32C051xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RCC_UseHSEasSystemClock.hex
  ILINK.IlinkOutputFile: RCC_UseHSEasSystemClock.out
  ILINK.IlinkIcfFile: stm32c051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c051xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c

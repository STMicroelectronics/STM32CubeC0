# Keil uVision project SMBUS_TwoBoards_ComIT_Master.uvprojx, settings and files
target SMBUS_TwoBoards_ComIT_Master (6210000::V6.21::ARMCLANG)
  device: STM32C051C8Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.2.0-RC2
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: SMBUS_TwoBoards_ComIT_Master +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C051xx
  c include: ../Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32C0xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32c051xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32C0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32C0xx_Nucleo/: stm32c0xx_nucleo.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_smbus.c stm32c0xx_hal_smbus_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 5.6.0

# Keil uVision project HAL_TimeBase_TIM.uvprojx, settings and files
target HAL_TimeBase_TIM (6140001::V6.14.1::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: HAL_TimeBase_TIM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C071xx
  c include: ../Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32C0xx_Nucleo
  group Application/MDK-ARM
    ./: startup_stm32c071xx.s
  group Application/User
    ../Src/: stm32c0xx_hal_timebase_tim.c main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32C0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32C0xx_Nucleo/: stm32c0xx_nucleo.c
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0

# Keil uVision project I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init.uvprojx, settings and files
target I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init (6210000::V6.21::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C071xx
  c include: ../Inc;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32c071xx.s
  group Application/User
    ../Src/: main.c stm32c0xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_dma.c stm32c0xx_ll_i2c.c stm32c0xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0

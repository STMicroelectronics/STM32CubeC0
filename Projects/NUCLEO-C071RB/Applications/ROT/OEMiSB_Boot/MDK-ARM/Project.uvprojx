# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-C071RB_OEMiSB_Boot (6190000::V6.19::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.1.0-RC1
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM1(0x08000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: $PROJ_FNAME$
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\OEMiSB_Boot.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32C071xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<mbed-crypto_config.h>,FLOW_CONTROL,FIH_ENABLE_DELAY
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32C0xx_Nucleo;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32c0xx_app.sct
  group Doc
    ../: README.md
  group Applications/User
    ../Src/: main.c stm32c0xx_it.c boot.c low_level_rng.c low_level_security.c entropy.c stm32c0xx_hal_msp.c
  group Applications/MDK-ARM
    ./: startup_stm32c071xx.s
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_ll_utils.c stm32c0xx_hal_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: sha256.c platform_util.c
software components: CMSIS:CORE 5.6.0

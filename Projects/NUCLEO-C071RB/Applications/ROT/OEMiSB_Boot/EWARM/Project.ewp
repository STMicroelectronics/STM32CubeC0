# IAR project Project.ewp, settings and files
configuration NUCLEO-C071RB_OEMiSB_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32C071RB ST STM32C071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C071xx; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE="mbed-crypto_config.h"; FLOW_CONTROL; FIH_ENABLE_DELAY
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include; ..\..\..\..\..\..\Drivers\STM32C0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32C0xx_Nucleo; ../../../../../../Middlewares/Third_Party/mbed-crypto/include; ../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiSB_Boot.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32c071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/User
    ../Src/: main.c stm32c0xx_it.c boot.c low_level_rng.c low_level_security.c entropy.c stm32c0xx_hal_msp.c
  group Applications/EWARM
    ./: startup_stm32c071xx.s
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: sha256.c platform_util.c

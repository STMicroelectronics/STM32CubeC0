# IAR project Project.ewp, settings and files
configuration NUCLEO-C071RB_OEMiSB_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32C071RB ST STM32C071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C071xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include; ..\..\..\..\..\..\Drivers\STM32C0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32C0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiSB_Appli.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32c071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/User
    ../Src/: main.c stm32c0xx_it.c
  group Applications/EWARM
    ./: startup_stm32c071xx.s
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c stm32c0xx_hal_wwdg.c stm32c0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c

# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-C071RB_OEMiSB_Appli (6190000::V6.19::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.1.0-RC1
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20002000,0x2000) IROM1(0x08000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: $PROJ_FNAME$
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\OEMiSB_Appli.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32C071xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../../../../../../Drivers/STM32C0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32C0xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: stm32c0xx_app.sct
  group Doc
    ../: README.md
  group Applications/User
    ../Src/: main.c stm32c0xx_it.c
  group Applications/MDK-ARM
    ./: startup_stm32c071xx.s
  group Drivers/STM32C0xx_HAL_Driver
    ../../../../../../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c stm32c0xx_hal_wwdg.c stm32c0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 4.3.0
